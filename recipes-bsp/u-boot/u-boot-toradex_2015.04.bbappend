FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI_append = " file://0001-apalis_imx6-Add-OSTree-boot.patch \
"

