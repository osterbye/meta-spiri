FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI_append = " file://0001-dk-add-MNC-20-and-66-to-Telia.patch \
"

