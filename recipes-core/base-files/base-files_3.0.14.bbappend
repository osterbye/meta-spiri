do_install_basefilesissue_append() {
    echo "Spiri CCU distribution" >> ${D}${sysconfdir}/issue
}

